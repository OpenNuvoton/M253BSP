# Keil uVision project Blinky.uvprojx, settings and files
target Blinky (6240000::V6.24::ARMCLANG)
  device: M253LE3AE Nuvoton
  pack: Nuvoton.NuMicroM23_DFP.1.0.1
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M23") CLOCK(12000000) IROM2(0x00100000,0x1000)
  output: Blinky
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=2
  c misc: -Wconditional-uninitialized
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\ThirdParty\FreeRTOS\Source\include;..\..\..\..\ThirdParty\FreeRTOS\Source\portable\GCC\ARM_CM23_NTZ\non_secure;..\..\..\..\ThirdParty\FreeRTOS\Demo\Common\include;..\..\Blinky;..\..\..\..\Library\Device\Nuvoton\M253\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\..\..\..\Library\Device\Nuvoton\M253\Source\ARM\APROM.scf
  group CMSIS
    ../../../../Library/Device/Nuvoton/M253/Source/: system_M253.c
    ../../../../Library/Device/Nuvoton/M253/Source/ARM/: startup_M253.c
  group Libraries
    ../../../../Library/StdDriver/src/: retarget.c clk.c sys.c uart.c
  group User
    ../: main.c main-blinky.c main-full.c Reg_Test.c ParTest_M253.c
  group FreeRTOS
    ../../../../ThirdParty/FreeRTOS/Source/portable/GCC/ARM_CM23_NTZ/non_secure/: port.c portasm.c
    ../../../../ThirdParty/FreeRTOS/Source/: timers.c list.c queue.c tasks.c
    ../../../../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group CommonDemo
    ../../../../ThirdParty/FreeRTOS/Demo/Common/Minimal/: dynamic.c recmutex.c blocktim.c countsem.c QueueSet.c QueueOverwrite.c
