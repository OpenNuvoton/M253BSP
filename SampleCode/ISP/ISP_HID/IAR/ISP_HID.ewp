# IAR project ISP_HID.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M253AE series Nuvoton M253AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\Device\Nuvoton\M253\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ISP_HID.bin
  ILINK.IlinkOutputFile: ISP_HID.out
  ILINK.IlinkIcfFile: ..\..\..\..\Library\Device\Nuvoton\M253\Source\IAR\LDROM.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M253/Source/IAR/: startup_M253_isp.s
    ../../../../Library/Device/Nuvoton/M253/Source/: system_M253.c
  group User
    ../: descriptors.c fmc_user.c hid_transfer.c isp_user.c main.c targetdev.c usbd_user.c
