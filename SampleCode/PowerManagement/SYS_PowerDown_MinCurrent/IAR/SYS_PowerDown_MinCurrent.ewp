# IAR project SYS_PowerDown_MinCurrent.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M253AE series Nuvoton M253AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\Device\Nuvoton\M253\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SYS_PowerDown_MinCurrent.bin
  ILINK.IlinkOutputFile: SYS_PowerDown_MinCurrent.out
  ILINK.IlinkIcfFile: M253.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M253/Source/IAR/: startup_M253.s
    ../../../../Library/Device/Nuvoton/M253/Source/: system_M253.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c gpio.c retarget.c sys.c timer.c uart.c wdt.c
  group User
    ../: main.c
