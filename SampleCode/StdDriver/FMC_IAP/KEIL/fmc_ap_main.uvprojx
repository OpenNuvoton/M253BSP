# Keil uVision project fmc_ap_main.uvprojx, settings and files
target fmc_ap_main (6120000::V6.12::.\ARMCLANG)
  device: M253LE3AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.10
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: fmc_ap_main
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Library\Device\Nuvoton\M253\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --map --first='startup_M253.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M253/Source/: system_M253.c
    ../../../../Library/Device/Nuvoton/M253/Source/ARM/: startup_M253.s
  group User
    ../: aprom_main.c
    ./: ap_image.s
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c uart.c sys.c fmc.c
