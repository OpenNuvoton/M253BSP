<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\USBD_VCOM_MultiPort_CMD.ewp</path>
  </project>
  <batchBuild/>
</workspace>


