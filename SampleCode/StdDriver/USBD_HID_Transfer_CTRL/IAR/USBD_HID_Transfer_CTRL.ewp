# IAR project USBD_HID_Transfer_CTRL.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M253AE series Nuvoton M253AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 56
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\Device\Nuvoton\M253\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBD_HID_Transfer_CTRL.bin
  ILINK.IlinkOutputFile: USBD_HID_Transfer_CTRL.out
  ILINK.IlinkIcfFile: M253.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M253/Source/IAR/: startup_M253.s
    ../../../../Library/Device/Nuvoton/M253/Source/: system_M253.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c usbd.c
  group User
    ../: descriptors.c hid_transfer.c main.c
