# IAR project FMC_MultiBoot_BootLD.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M253AE series Nuvoton M253AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: __LDROM__
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\Device\Nuvoton\M253\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FMC_MultiBoot_BootLD.bin
  ILINK.IlinkOutputFile: FMC_MultiBoot_BootLD.out
  ILINK.IlinkIcfFile: FMC_MultiBoot_BootLD.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M253/Source/IAR/: startup_M253.s
    ../../../../Library/Device/Nuvoton/M253/Source/: system_M253.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c fmc.c retarget.c sys.c uart.c
  group User
    ../: main.c
