# IAR project SPI_Flash.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M253AE series Nuvoton M253AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 56
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: $PROJ_DIR$..\..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\M253\Include; $PROJ_DIR$..\..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SPI_Flash.bin
  ILINK.IlinkOutputFile: SPI_Flash.out
  ILINK.IlinkIcfFile: M253.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M253/Source/IAR/: startup_M253.s
    ../../../../Library/Device/Nuvoton/M253/Source/: system_M253.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c spi.c sys.c uart.c
  group User
    ../: main.c
