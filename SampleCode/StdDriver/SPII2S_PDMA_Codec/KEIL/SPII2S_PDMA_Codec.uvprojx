# Keil uVision project SPII2S_PDMA_Codec.uvprojx, settings and files
target SPII2S_PDMA_Codec (6240000::V6.24::ARMCLANG)
  device: M253LE3AE Nuvoton
  pack: Nuvoton.NuMicroM23_DFP.1.0.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: SPII2S_PDMA_Codec
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=2
  c include: ..\..\..\..\Library\Device\Nuvoton\M253\Include;..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ..\..\..\..\Library\Device\Nuvoton\M253\Source\ARM\APROM.sct
  link misc: --pd="-DFLASH_SIZE=0x40000 -DSRAM_SIZE=0x4000 -DSTACK_SIZE=0x800 -DHEAP_SIZE=0x800"
  group CMSIS
    ../../../../Library/Device/Nuvoton/M253/Source/: system_M253.c
    ../../../../Library/Device/Nuvoton/M253/Source/ARM/: startup_M253.c
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c spi.c clk.c uart.c pdma.c sys.c gpio.c i2c.c
